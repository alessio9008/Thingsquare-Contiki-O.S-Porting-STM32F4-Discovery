# IAR project contiki-os-stm32l1xx-mesh-node.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MIST_TARGET=\"mist-spirit1\"; UIP_CONF_IPV6=1; UIP_CONF_IPV6_RPL=1; CONTIKI=1; CONTIKI_TARGET_MIST_SPIRIT1_F4=1; WITH_UIP6=1; IAR=1; HSE_VALUE=32000000ul; USE_STDPERIPH_DRIVER; STM32L1XX_MD; IAR_ARM_CM4; VECT_TAB_FLASH; WITH_UIP6; AUTOSTART_ENABLE
  ICCARM.IExtraOptions: --diag_suppress Pa050; --no_unroll; --no_inline; --no_tbaa; --no_scheduling; --debug; -e
  ICCARM.CCIncludePath2: ..\..\..\contiki\cpu\arm\stm32l152\; ..\..\..\contiki\cpu\arm\stm32l152\SpiritSDK_Virtual_Com\inc; ..\..\..\contiki\cpu\arm\stm32l152\STM32_USB-FS-Device_Lib\inc; ..\..\..\contiki\core\; ..\..\..\contiki\core\loader\; ..\..\..\contiki\core\net\; ..\..\..\contiki\core\sys\; ..\..\..\contiki\core\dev\; ..\..\..\contiki\core\lib\; ..\..\..\contiki\core\net\rpl\; ..\..\..\contiki\core\net\mac\; ..\..\..\contiki\core\net\rime\; ..\..\..\apps\mist-conf\; ..\..\..\apps\aes\; ..\..\..\platform\mist-spirit1\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\mist-spirit1\dev\sdk\; ..\..\..\platform\mist-spirit1\dev\spirit1\; ..\..\..\platform\mist-spirit1\dev\; ..\..\..\platform\mist-spirit1\; ..\..\..\apps\aes\; ..\..\..\examples\blink\; ..\..\..\examples\router-node\; ..\..\..\apps\ip64\; ..\..\..\apps\ip64-addr\; ..\..\..\apps\mdns\; ..\..\..\apps\simple-rpl\; ..\..\..\apps\tcp-socket\; ..\..\..\apps\udp-socket\; ..\..\..\apps\websocket\; ..\..\..\apps\ip64-webserver\; ..\..\..\contiki\apps\webserver\; ..\..\..\apps\simple-udp-ping\; ..\..\..\apps\network-reboot\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: contiki-os-stm32l1xx.srec
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkExtraOptions: --cpu=Cortex-M3; --semihosting; --redirect _Printf=_PrintfLarge; --redirect _Scanf=_ScanfLarge; --log_file contiki-mist-spirit1.log; --vfe
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group apps/aes
    ../../../apps/aes/: aes-ccm.c aes.c netstack-aes.c
  group apps/drowsie
    ../../../apps/drowsie/: drowsie.c
  group apps/drowsie-multichannel
    ../../../apps/drowsie-multichannel/: drowsie-multichannel.c
  group apps/ip64
    ../../../apps/ip64/: ip64-addrmap.c ip64-arp.c ip64-eth-interface.c ip64-eth.c ip64-ipv4-dhcp.c ip64-null-driver.c ip64-slip-interface.c ip64-special-ports.c ip64-tap-driver.c ip64.c
  group apps/ip64-addr
    ../../../apps/ip64-addr/: ip64-addr.c
  group apps/ip64-webserver
    ../../../apps/ip64-webserver/: httpd-cgi.c httpd-fs.c httpd.c ip64-webserver.c
  group apps/mdns
    ../../../apps/mdns/: mdns.c
  group apps/simple-rpl
    ../../../apps/simple-rpl/: simple-rpl.c
  group apps/simple-udp-ping
    ../../../apps/simple-udp-ping/: simple-udp-ping.c
  group apps/tcp-socket
    ../../../apps/tcp-socket/: tcp-socket.c
  group apps/udp-socket
    ../../../apps/udp-socket/: udp-socket.c
  group apps/websocket
    ../../../apps/websocket/: http-strings.c websocket-http-client.c websocket.c
  group core
    ../../../platform/mist-spirit1/: contiki-spirit1-main.c node-id.c
  group core/dev
    ../../../contiki/core/dev/: leds.c
  group core/lib
    ../../../contiki/core/lib/: assert.c checkpoint.c crc16.c ifft.c list.c memb.c mmem.c print-stats.c random.c ringbuf.c
  group core/loader
    ../../../contiki/core/loader/: elfloader.c
  group core/net
    ../../../contiki/core/net/: dhcpc.c hc.c neighbor-attr.c neighbor-info.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../contiki/core/net/mac/: contikimac.c csma.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c xmac.c
  group core/net/rime
    ../../../contiki/core/net/rime/: rimeaddr.c rimestats.c
  group core/net/rpl
    ../../../contiki/core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-of-etx.c rpl-of0.c rpl-timers.c rpl.c
  group core/rime
    ../../../contiki/core/net/rime/: broadcast.c channel.c route-discovery.c route.c trickle.c unicast.c
  group core/sys
    ../../../contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group dev
    ../../../platform/mist-spirit1/dev/: leds-arch.c spirit1-arch.c spirit1.c
  group dev/sdk
    ../../../platform/mist-spirit1/dev/sdk/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Led.c SDK_EVAL_PM.c SDK_EVAL_Spirit_Gpio.c SDK_EVAL_Spirit_Spi_Driver.c SDK_EVAL_Timers.c
  group dev/spirit1
    ../../../platform/mist-spirit1/dev/spirit1/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Regs.h SPIRIT_Timer.c SPIRIT_Types.c
  group MAIN
    ../../../contiki/cpu/arm/stm32l152/: clock.c rtimer-arch.c startup_stm32l1xx_md.s system_stm32l1xx.c watchdog.c
  group mesh-node
    ../../../examples/udp-multicast/: udp-multicast.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/mist-spirit1/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_it.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_tim.c
  group USB
    ../../../contiki/cpu/arm/stm32l152/STM32_USB-FS-Device_Lib/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group VC
    ../../../contiki/cpu/arm/stm32l152/SpiritSDK_Virtual_Com/src/: SDK_EVAL_VC_Desc.c SDK_EVAL_VC_Endp.c SDK_EVAL_VC_General.c SDK_EVAL_VC_Istr.c SDK_EVAL_VC_Prop.c SDK_EVAL_VC_Pwr.c
